# IAR project DAB_Inverter.ewp, settings and files
configuration DAB_Inverter (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DAB_Inverter.hex
  ILINK.IlinkOutputFile: DAB_Inverter.out
  ILINK.IlinkIcfFile: stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f303xc.s
  group Application/User
    ../Src/: printf.c sine_table.c main.c gpio.c adc.c can.c dma.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
    ../Inc/: sine_table.h
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_can.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
